/***
 *	eigene Windowelemente
 ***/

#include "WindElement.h"

#if USEWINDELEMENT
Boolean		TrackWindItem(REG WindPtr wind,Point p,short thePart)
{
Rect	r;
Boolean	status = false;
Boolean	flag;
GrafPtr	savePort;

	GetPort(&savePort);
	SetPort((GrafPtr)wind);
	r.top = thePart;
	CallWind(wind,wItemRect,(long)&r);	// Rechteck vom Objekt errechnen
	do {
		flag = PtInRect(p,&r);			// nicht im Rechteck?
		if (status != flag) {			// Button verŠndert?
			CallWind(wind,wItemDraw,((long)flag<<16) | thePart);	// Image blitten
			status = flag;
		}
		GetMouse(&p);					// neue Mausposition abfragen
		LocalToGlobal(&p);
	} while(WaitMouseUp());				// bis auf Maustaste los warten
	SetPort(savePort);
	return(status);						// Status zurŸckgeben
}

#if 0
/***
 *	bei jedem Fenster ein zusŠtzliches Randelement
 ***/
void	WindInit(WindPtr wind)
{
	AddWindItem(wind,128,129);			// Item an die Liste anfŸgen
}

/***
 *	und eine Routine zur Verwaltung des Randelementes
 ***/
void	WindElement(REG WindPtr wind,Point p,short thePart)
{
	if (TrackWindItem(wind,p,thePart)) {// Objekt selektiert?
		SysBeep(1);						// Ja!
	}
	DeselectWindItem(wind,thePart);		// Objekt deselektieren
}
#endif
#endif
