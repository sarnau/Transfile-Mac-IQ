/***
 *	Library fŸr die serielle Schnittstelle
 ***/

#define SERDEBUG		0
#define CTB				1

#include "SerialComm.h"
#include "GlobalLib.h"
#include "Utilities.h"
#if SERDEBUG
#include <stdio.h>
#endif
#include <Serial.h>
#if CTB
#include <CommResources.h>
#include <CRMSerialDevices.h>
#endif

Str63		SDName;			// Name des aktiven Ports
WORD		SDIn,SDOut;		// RefNum fŸr Lesen und Schreiben
WORD		SDPort = 0;		// aktueller Ausgabeport
USTR		SDInBuf;		// Buffer fŸr den Eingang
WORD		SDBreakChar;	// Break-Char (-1 = keins)
UWORD		SDChecksum;		// PrŸfsumme fŸr Lesen VOM Organizer
UWORD		SDTimeout;		// TimeoutlŠnge beim Empfang in 60Hz

char PortAUse : 0x290;		// sind in der Think C Library nicht definiert
char PortBUse : 0x291;
char SpConfig : 0x1FB;

/***
 *	alle seriellen Ports ermitteln
 ***/
VOID	SDLookup(Boolean (*callback)(WORD index,USTR portname,USTR indriver,USTR outdriver))
{
REG CRMRecPtr		theCRM;
CRMRec				theCRMRec;
REG CRMSerialPtr	theSerial;
REG WORD			old,index;
REG Boolean			flag;
CHAR				index1,index2,index3;

	if (gCTB) {								// CTB vorhanden?
		old = 0;							// ID des Ports
		index = 1;							// Index des Ports
		while(1) {
			theCRMRec.crmDeviceType = crmSerialDevice;
			theCRMRec.crmDeviceID = old;
			theCRM = &theCRMRec;
			theCRM = (CRMRecPtr)CRMSearch(theCRM); // Port suchen
			if (!theCRM) 
				break;						// keinen weiteren Port gefunden => raus
			theSerial = (CRMSerialPtr)(theCRM->crmAttributes);
			index1 = HGetState((Handle)theSerial->name);
			index2 = HGetState((Handle)theSerial->inputDriverName);
			index3 = HGetState((Handle)theSerial->outputDriverName);
			HLock((Handle)theSerial->name);
			HLock((Handle)theSerial->inputDriverName);
			HLock((Handle)theSerial->outputDriverName);
			flag = (*callback)(index,*(theSerial->name),*(theSerial->inputDriverName),
							*(theSerial->outputDriverName));
			HSetState((Handle)theSerial->name,index1);
			HSetState((Handle)theSerial->inputDriverName,index2);
			HSetState((Handle)theSerial->outputDriverName,index3);
			if (flag) break;				// Treiber gefunden => raus
			old = theCRM->crmDeviceID;		// der nŠchste Port
			index++;
		}
	} else {
		Str255		sName,sIn,sOut;

		for(index=1;;index++) {
			GetIndString(sName,1004,(index-1)*3+1);
			if (!sName[0]) break;
			GetIndString(sIn,1004,(index-1)*3+2);
			GetIndString(sOut,1004,(index-1)*3+3);
			if ((*callback)(index,sName,sIn,sOut)) break;
		}
	}
}

OSErr		SDCBOpenErr;

Boolean	SDCBOpen(WORD index,USTR portname,USTR indriver,USTR outdriver);
Boolean	SDCBOpen(WORD index,USTR portname,USTR indriver,USTR outdriver)
{
REG OSErr	err;

	if (!EqualString(portname,SDName,false,true)) return(false);	// Port gefunden?
	err = OpenDriver(indriver,&SDIn);
	if (err) {
		SDIn = 0;						// Ports lšschen
		SDCBOpenErr = err;
		return(true);					// Fehler beim …ffnen => Abbruch
	}
	err = OpenDriver(outdriver,&SDOut);
	if (err) {
		CloseDriver(SDIn);				// Eingangstreiber schlie§en
		SDIn = SDOut = 0;				// Ports lšschen
		SDCBOpenErr = err;
		return(true);					// Fehler beim …ffnen => Abbruch
	}
	SDPort = index;						// aktiver Port
	SDCBOpenErr = noErr;
	return(true);
}

/***
 *	seriellen Port wieder abmelden
 ***/
OSErr	SDClose(VOID)
{
REG OSErr	err = noErr;

	if (SDInBuf) {			// seriellen Buffer freigeben
		SerSetBuf(SDIn,nil,(short)nil);
		DisposPtr((Ptr)SDInBuf);
		SDInBuf = nil;
	}
	if (SDIn) {				// seriellen Port schlie§en
		err = CloseDriver(SDIn);
		SDIn = 0;
	}
	if (SDOut) {
		if (err)
			CloseDriver(SDOut);
		else
			err = CloseDriver(SDOut);
		SDOut = 0;
	}
	SDPort = 0;
	return(err);
}

/***
 *	seriellen Port mit 9600 Baud 8N1 XON/XOFF anmelden
 ***/
OSErr	SDOpen(VOID)
{
SerShk			s;
REG OSErr		err;

	if (SDPort>0) SDClose();
	SDLookup(SDCBOpen);			// Treiber suchen und šffnen
	if (SDCBOpenErr) return(SDCBOpenErr);	// kein Treiber gefunden!

	SDTimeout = 60;				// Timeout = 1s
	SDBreakChar = -1;			// kein Break-Zeichen
	err = SerReset(SDOut,SDInitPara);
	if (err) {
		SDClose();
		return(err);
	}
	err = SerReset(SDIn,SDInitPara);
	if (err) {
		SDClose();
		return(err);
	}
	s.fXOn = true;	// XON/XOFF fŸr den Ausgabe aktivieren
	s.fCTS = 0;		// CTS-Handshake aus
	s.xOn = XOn;	// Zeichencode von XON
	s.xOff = XOff;	// Zeichencode von XOFF
	s.errs = parityErr + hwOverrunErr + framingErr;	// Abbruch-Conditions
	s.evts = 0;		// keine Driver-Events posten
	s.fInX = true;	// XON/XOFF fŸr die Eingabe aktivieren
#if 0	// Siehe Q&A Stack
	err = SerHShake(SDIn,&s);
	if (err) {
		SDClose();
		return(err);
	}
#endif
	err = SerHShake(SDOut,&s);
	if (err) {
		SDClose();
		return(err);
	}
	SDInBuf = (USTR)NewPtr(SERIALBUF);
	if (SDInBuf)			// grš§eren Buffer fŸr den Eingang
		SerSetBuf(SDIn,(Ptr)SDInBuf,SERIALBUF);
	return(err);
}

/***
 *	auf Bytes an der Seriellen warten
 ***/
OSErr	SDWait(REG UWORD timeout,REG LONG *count)
{
REG OSErr	err;
REG ULONG	time = TickCount() + timeout;
REG Boolean	flag = false;

	while(true) {
		if (time < TickCount()) flag = true;// Timeout?
		err = SerGetBuf(SDIn,(long*)count);	// Bytes im In-Buffer abfragen
		if (err) return(err);				// OS-Error
		if (*count > 0) return(noErr);		// es sind Bytes da
		if (UserAbort()) return(userCanceledErr); // Anwender bricht ab
		if (flag) return(1);				// Timeout
	}
}

/***
 *	String der LŠnge ÒlenÓ im Stdio-Window mit Steuerzeichen ausgeben
 ***/
#if SERDEBUG
void		DebugPrint(STR header,USTR s,UWORD len);
void		DebugPrint(STR header,USTR s,UWORD len)
{
REG WORD	i;
REG UCHAR	cc;
static UCHAR tab[] = {
		"NULSOHSTXETXEOTENQACKBELBS TABLF VT FF CR SO SI "
		"DLEDC1DC2DC3DC4NAKSYNETBCANEM SUBESCFS GS RS US " };
static FILE	*f = nil;

	if (!f) {
		f = stdout;
//		f = fopen("INPUT","w+");
	}
	fprintf(f,"%s",header);
	for(i=0;i<len;i++) {
		cc = s[i];
		if (cc < 32) {
			cc *= 3;
			if (tab[cc+2] == ' ')
				fprintf(f,"<%c%c:%d>",tab[cc],tab[cc+1],s[i]);
			else
				fprintf(f,"<%c%c%c:%d>",tab[cc],tab[cc+1],tab[cc+2],s[i]);
		} else {
			REG WORD j = i; REG BYTE temp;
			while((s[i]>=32)&&(i<len)) i++;
			temp = s[i]; s[i] = 0;
			fprintf(f,"%s",&s[j]);
			s[i--] = temp;
		}
	}
	fprintf(f,"\n",SDChecksum);
}
#endif

/***
 *	einen String Ÿber die serielle Schnittstelle senden
 ***/
OSErr	SDWrite(REG USTR s,REG UWORD count)
{
REG OSErr	err;
LONG		c = count;

#if SERDEBUG
	DebugPrint("MAC:",s,count);
#endif
	err = FSWrite(SDOut,&c,s);			// String senden
	if ((count != c)&&(err == noErr))
		err = ioErr;					// Bytes nicht gesendet
	if (!err) {
		REG WORD	i;
		for(i=0;i<count;i++)			// PrŸfsumme Ÿber den String
			SDChecksum += (UWORD)s[i];	// PrŸfsumme updaten
	}
	if (UserAbort()) return(userCanceledErr); // Anwender bricht ab
	return(err);
}

/***
 *	zwei Bytes (Befehl) Ÿber die serielle Schnittstelle senden
 ***/
OSErr	SDWriteCmd(UWORD cmd)
{
	return(SDWrite((USTR)&cmd,2));
}

/***
 *	count Bytes Ÿber die serielle Schnittstelle einlesen
 ***/
OSErr	SDRead(REG USTR buf,REG UWORD maxbytes)
{
REG OSErr	err;		// Fehlercode, der letzten Operation
LONG		count;		// Anzahl der vorhandenen/gelesenen Bytes
REG UWORD	sum = 0;	// Anzahl der gelesenen Bytes
#if SERDEBUG
USTR		bufstart = buf;	// Anfangsadresse vom Empfangsbuffer
#endif

	do {
		err = SDWait(SDTimeout,&count);	// 1s Timeout
		if ((err)||(!count)) break;		// Abbruch, wenn Fehler, oder alles gelesen
		count = 1;
		err = FSRead(SDIn,&count,buf);	// ein Byte aus dem Buffer einlesen
		if (err) break;					// Abbruch, wenn Fehler
		if (count != 1) return(ioErr);	// Es fehlen Bytes!
		sum++;							// Zeichen zŠhlen
		SDChecksum += (unsigned short)*buf;	// PrŸfsumme updaten
		if ((SDBreakChar>=0)&&(*buf == SDBreakChar)) {
#if SERDEBUG
			DebugPrint("IQ :",bufstart,sum);
#endif
			return(sum);				// Break-Char gefunden?
		}
		buf++;							// zum nŠchsten Zeichen
	} while(sum < maxbytes);			// alle Bytes gelesen?
	if (err<0) return(err);				// Fehlercode zurŸckgeben
	if (!sum) return(volOffLinErr);		// keine Antwort!
#if SERDEBUG
	DebugPrint("IQ :",bufstart,sum);
#endif
	return(sum);						// Anzahl der gelesenen Bytes
}

/***
 *	Break-Char setzen
 ***/
VOID	SDSetBrk(WORD brk)
{
	SDBreakChar	= brk;
}
