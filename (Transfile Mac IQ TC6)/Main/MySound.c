//
//	MySound.c
//

#include "SoundInput.h"
#include "Sound.h"
#include "MySound.h"

#define SOUND_COUNT		8	// Anzahl der Sounds pro Typ

short geileSounds[4][SOUND_COUNT]={
{128,6000,19902,0,0,0,0,0},					// About
{6000,19902,32329,0,0,0,0,0},				// Positive
{138,139,6001,6002,17716,0,0,0},			// Sorry
{131,132,133,139,141,28357,31393,32135}};	// Crash

void	OwnBeep(mood whichType)
{
REG Handle			sndHandle;
REG	unsigned short	which;

	if (LMGetSdVolume() == 0) return;					// Sound ist aus! => nix abspielen
	do{
		which=Random();
		which/=(65536/SOUND_COUNT);				// Zufallszahl zwischen 0 und Anzahl der Sounds
		which=geileSounds[whichType][which];	// Resourcenummer holen
	}while(!which);
	sndHandle=GetResource('snd ',which);
	if(sndHandle) {
		SndPlay(nil,sndHandle,false);
		HPurge(sndHandle);
	} else
		SysBeep(20);
}